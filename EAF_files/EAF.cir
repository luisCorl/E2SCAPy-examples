R1 4 1 R
R2 2 4 R
R3 4 3 R
R4 2 1 R
R5 2 3 R
R6 3 1 R
V1 1 0 V
V2 2 0 V
V3 3 0 V
