R1 1 0 0.2
R2 4 1 0.2
R3 5 4 1e3
R4 1 2 0.2
R5 3 9 0.2
R6 3 0 1e3
R7 0 3 0.2
R8 7 0 0.2
R9 7 0 0.2
R10 8 6 0.2
R11 8 2 0.2
R12 0 8 1e3
R13 7 9 1e3
C1 6 5 0.0025
O1 1 3 4
O2 5 0 6
O3 7 8 9
V1 2 0 Symbol
